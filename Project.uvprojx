# Keil uVision project Project.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\CMSIS\Include;.\Drivers;.\Users;.\Drivers\SYSTEM\delay;.\Drivers\SYSTEM\sys;.\Drivers\SYSTEM\usart;.\Drivers\BSP;.\Drivers\SYSTEM\RTC;.\Drivers\SYSTEM\spi;.\Drivers\SYSTEM\ADC;.\Drivers\SYSTEM\mqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group Drivers/STM32F1xx_HAL_Driver
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/SYSTEM
    ./Drivers/SYSTEM/delay/: delay.c
    ./Drivers/SYSTEM/sys/: sys.c
    ./Drivers/SYSTEM/spi/: my_SPI.c
    ./Drivers/SYSTEM/RTC/: myRTC.c
    ./Drivers/SYSTEM/usart/: uart1.c
    ./Drivers/SYSTEM/ADC/: my_ADC.c
    ./Drivers/SYSTEM/mqtt/: MqttKit.c
  group Drivers/BSP
    ./Drivers/BSP/: OLED.c keyboard.c oled_show.c W25Q128.c pwd.c beep.c SU_03T.c BlueTooth.c systick_Task.c fan.c door_switch.c lamps.c DHT11.c esp8266.c onenet.c
  group User
    ./Users/: main.c stm32f1xx_it.c
    ./Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
